# Keil uVision project SimplSLEEP_TmrWakeup.uvprojx, settings and files
target SWM181 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SWM181xB Synwit
  pack: Synwit.SWM32_DFP.1.8.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1E000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SimplSLEEP_TmrWakeup
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c include: ..\..\SWM181_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM181_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM181_StdPeriph_Driver\CSL\SWM181_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ./app/: main.c
  group CSL\StdPD
    ../../SWM181_StdPeriph_Driver/CSL/SWM181_StdPeriph_Driver/: SWM181_adc.c SWM181_cmp.c SWM181_exti.c SWM181_gpio.c SWM181_i2c.c SWM181_pwm.c SWM181_timr.c SWM181_uart.c SWM181_wdt.c SWM181_can.c SWM181_cordic.c SWM181_div.c SWM181_dma.c SWM181_flash.c SWM181_irqmux.c SWM181_port.c SWM181_sdadc.c SWM181_slcd.c SWM181_spi.c SWM181_cache.c SWM181_sleep.c
  group CSL\CMSIS
    ../../SWM181_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM181.c
    ../../SWM181_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM181.s
software components: CMSIS:CORE 5.3.0
