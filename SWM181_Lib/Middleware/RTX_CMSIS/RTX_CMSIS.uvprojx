# Keil uVision project RTX_CMSIS.uvprojx, settings and files
target SWM181 (ARM-ADS)
  device: SWM181xB Synwit
  pack: Synwit.SWM32_DFP.1.6.4
  cpu: IROM(0x00000000,0x1E000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RTX_CMSIS
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ./APP/: main.c
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Device:Driver:GPIO 1.5.0, Device:Driver:IRQMux 1.5.0, Device:Driver:PWM 1.5.0, Device:Driver:Port 1.5.0, Device:Driver:SDADC 1.5.0, Device:Driver:Timer 1.5.0, Device:Driver:UART 1.5.0, Device:Startup 1.6.0
